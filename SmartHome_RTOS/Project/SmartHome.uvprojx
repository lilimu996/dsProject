# Keil uVision project SmartHome.uvprojx, settings and files
target SmartHome_SingleTask (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartHome +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\App;..\Core;..\Device;..\HAL;..\MiddleWare;..\ModuleDrivers;..\Platform;..\Project;..\Protocol;..\HAL\STM32F1xx_HAL_Driver\Src;..\HAL\STM32F1xx_HAL_Driver\Inc;..\HAL\CMSIS\Device\ST\STM32F1xx\Include;..\HAL\CMSIS\Include;..\HAL\SYSTEM\sys;..\MiddleWare\FreeRTOS-Kernel\portable\RVDS\ARM_CM3;..\MiddleWare\FreeRTOS-Kernel\portable\MemMang;..\MiddleWare\FreeRTOS-Kernel\include;..\Protocol\MQTTClient-C\src;..\Protocol\MQTTClient-C\src\FreeRTOS;..\Protocol\MQTTPacket\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group HAL
    ../HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
    ../HAL/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.h stm32f1xx_hal_dma.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h
    ../HAL/SYSTEM/sys/: sys.c sys.h
  group App
    ../App/: main.h main.c app_mqtt.c app_led.c app_key.c
    ../Protocol/MQTTClient-C/samples/FreeRTOS/: MQTTEcho.c
  group Core
    ../Core/: stm32f1xx_hal_conf.h stm32f1xx_it.c system_stm32f1xx.c
    ./: startup_stm32f103xe.s
  group Device
    ../Device/: dev_io.c dev_io.h dev_net.c dev_net.h
  group MiddleWare/FreeRTOS
    ../MiddleWare/: FreeRTOSConfig.h
    ../MiddleWare/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../MiddleWare/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../MiddleWare/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group ModuleDrivers
    ../ModuleDrivers/: driver_buffer.c driver_buffer.h driver_led_key.c driver_led_key.h driver_dbg.c driver_dbg.h driver_net.c driver_net.h driver_hal_timebase.c
  group Platform
    ../Platform/: platform_io.c platform_io.h platform.h platform_net.h platform_net.c
  group Protocol/MQTTClient-C
    ../Protocol/MQTTClient-C/src/: MQTTClient.c
    ../Protocol/MQTTClient-C/src/FreeRTOS/: MQTTFreeRTOS.c
  group Protocol/MQTTPacket
    ../Protocol/MQTTPacket/src/: CMakeLists.txt MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
target SmartHome_MultTask (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: SmartHome +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
